# Keil uVision project ENS001_BASIC_PRJ.uvprojx, settings and files
target ENS001_BASIC_PRJ (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ENS001_BASIC_PRJ +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORTEX_M0
  c include: .\CORE\INCLUDE;.\USER;.\FWLIB\include
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./USER/: mian.c
  group FWLIB
    ./FWLIB/include/: ENS1_UART.h ENS1_GPIO.h ENS1_MTP.h ENS1_CLOCK.h
    ./FWLIB/source/: ENS1_UART.c ENS1_GPIO.c ENS1_MTP.c ENS1_CLOCK.c retarget.c
  group CORE
    ./CORE/: system_CMSDK_CM0.c
    ./CORE/ARM/: startup_CMSDK_CM0.s
